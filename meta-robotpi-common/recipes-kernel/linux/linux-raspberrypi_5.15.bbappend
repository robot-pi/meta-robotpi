FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += " \
    file://usbc-driver-config.cfg \
    "