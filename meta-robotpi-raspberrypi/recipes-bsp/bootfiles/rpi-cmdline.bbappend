CMDLINE_RNDIS ?= ""
CMDLINE_RNDIS:append = " modules-load=dwc2,g_ether"