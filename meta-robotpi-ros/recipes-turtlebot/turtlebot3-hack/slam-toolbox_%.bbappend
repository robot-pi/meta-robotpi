ROS_EXEC_DEPENDS:remove = "ceres-solver"