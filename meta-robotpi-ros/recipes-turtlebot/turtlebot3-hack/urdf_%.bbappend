RDEPENDS:${PN} += "urdf-parser-plugin"