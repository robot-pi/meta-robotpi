SRCREV = "a50c80dbc6bbc4ec497950b675cabf47619cdbc7"

FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-rviz-rendering-remove-rviz_assimp_vendor-from-ament_.patch"

