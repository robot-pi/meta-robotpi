PACKAGECONFIG:append = " libomp"