PACKAGECONFIG:append:pn-python3 = " tk"