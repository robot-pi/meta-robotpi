PACKAGECONFIG:append = " gui"