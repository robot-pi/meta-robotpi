LICENSE_FLAGS_ACCEPTED:append = " commercial_ffmpeg"