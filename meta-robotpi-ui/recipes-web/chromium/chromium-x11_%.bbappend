PACKAGECONFIG:append:pn-chromium-x11 = " kiosk-mode"
